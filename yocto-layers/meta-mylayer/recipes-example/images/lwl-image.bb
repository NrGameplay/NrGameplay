require recipes-core/images/core-image-minimal.bb
IMAGE_INSTALL:append = " usbutils"
IMAGE_INSTALL:append = " myhello"
