require recipes-phosphor/images/obmc-phosphor-image.bb
IMAGE_INSTALL:append = " usbutils"
IMAGE_INSTALL:append = " myhello"
